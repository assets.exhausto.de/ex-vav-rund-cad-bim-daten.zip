Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\tmink\OneDrive - Vento\Bureaublad\A_Blazej\FINAL VAV\VAV-R400.IFC
Time: 2025-03-06T12:07:53+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcBuildingElementProxy: AECARCHITECTURALELEMENT (31)
In: default BuildingStorey
Name
KLAPPE400
BLECHSCHRAUBE | SOLIDWORKS Custom Properties - Definition: design; Nomenclature: Fusion; Part Number: Fusion; sets with these values: 2
BLECHSCHRAUBE-1 | SOLIDWORKS Custom Properties - Definition: design; Nomenclature: Fusion; Part Number: Fusion; sets with these values: 2
BELIMO_MOTOR BRACKET_DN500-630 | SOLIDWORKS Custom Properties - sets with these values: 2; Material: Verzinkter Stahl; Technische Referenz: KReiter; Weight: 0.15 kg
LDE_DN400
Dichtungen
2 x Abschlusskappexxx_x_x
2 x Dichtung_innenxxx_x_x
2 x Dichtung_Vierkantxxx_x_x
2 x Sicherungsscheibexxx_x_x
Label VAVR400
CROSS_DN400
VSRV_Zapfen
CROSS_WING400
CROSS_PIECE
CROSS_PLUG
CROSS_WING400-1
CROSS_WING400-2
CROSS_WING400-3
CROSS_PLUG-1
CROSS_PLUG-2
LMV-D3-MP
Dichtungen-1
BLECHSCHRAUBE-2 | SOLIDWORKS Custom Properties - Definition: design; Nomenclature: Fusion; Part Number: Fusion; sets with these values: 2
LDE_DN400-1
DB_DN400
Teil8^VAV-R400
