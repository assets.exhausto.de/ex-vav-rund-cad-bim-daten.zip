Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\tmink\OneDrive - Vento\Bureaublad\A_Blazej\FINAL VAV\VAV-RI125.IFC
Time: 2025-03-06T10:45:29+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcBuildingElementProxy: AECARCHITECTURALELEMENT (32)
In: default BuildingStorey
Name
DB_DN125
BELIMO_MOTOR BRACKET_DN125 | SOLIDWORKS Custom Properties - Material: Verzinkter Stahl; Technische Referenz: KReiter; Weight: 0,15 kg; sets with these values: 2
BLECHSCHRAUBE | SOLIDWORKS Custom Properties - sets with these values: 2; Definition: design; Nomenclature: Fusion; Part Number: Fusion
Dichtungen
2 x Abschlusskappexxx_x_x
2 x Sicherungsscheibexxx_x_x
2 x Dichtung_Vierkantxxx_x_x
2 x Dichtung_innenxxx_x_x
LDE_DN125
BLECHSCHRAUBE-1 | SOLIDWORKS Custom Properties - sets with these values: 2; Definition: design; Nomenclature: Fusion; Part Number: Fusion
Dichtungen-1
Isogehäuse
LDE_DN125-1
LMV-D3-MP
BLECHSCHRAUBE-2 | SOLIDWORKS Custom Properties - sets with these values: 2; Definition: design; Nomenclature: Fusion; Part Number: Fusion
CROSS_DN125
CROSS_WING125
VSRV_Zapfen
CROSS_PIECE
CROSS_PLUG
CROSS_PLUG-1
CROSS_PLUG-2
CROSS_WING125-1
CROSS_WING125-2
CROSS_WING125-3
KLAPPE125
Label VAVR125
Teil6^VAV-RI125
