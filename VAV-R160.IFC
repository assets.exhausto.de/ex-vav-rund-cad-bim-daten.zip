Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\tmink\OneDrive - Vento\Bureaublad\A_Blazej\FINAL VAV\VAV-R160.IFC
Time: 2025-03-10T13:40:20+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcBuildingElementProxy: AECARCHITECTURALELEMENT (31)
In: default BuildingStorey
Name
LDE_DN160
DB_DN160
CROSS_DN160
CROSS_PLUG
CROSS_WING160
CROSS_PLUG-1
CROSS_WING160-1
CROSS_WING160-2
CROSS_WING160-3
VSRV_Zapfen
CROSS_PIECE
CROSS_PLUG-2
BELIMO_MOTOR BRACKET_DN150-200 | SOLIDWORKS Custom Properties - Material: Verzinkter Stahl; Technische Referenz: KReiter; Weight: 0.15 kg; sets with these values: 2
BLECHSCHRAUBE | SOLIDWORKS Custom Properties - sets with these values: 2; Definition: design; Nomenclature: Fusion; Part Number: Fusion
BLECHSCHRAUBE-1 | SOLIDWORKS Custom Properties - sets with these values: 2; Definition: design; Nomenclature: Fusion; Part Number: Fusion
Dichtungen
2 x Dichtung_innenxxx_x_x
2 x Dichtung_Vierkantxxx_x_x
2 x Sicherungsscheibexxx_x_x
2 x Abschlusskappexxx_x_x
KLAPPE160
Label VAVR160
BLECHSCHRAUBE-2 | SOLIDWORKS Custom Properties - sets with these values: 2; Definition: design; Nomenclature: Fusion; Part Number: Fusion
LMV-D3-MP
Dichtungen-1
LDE_DN160-1
Teil3^VAV-R160
