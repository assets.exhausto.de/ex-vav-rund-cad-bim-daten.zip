Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\tmink\OneDrive - Vento\Bureaublad\A_Blazej\FINAL VAV\VAV-RI100.IFC
Time: 2025-03-06T11:39:07+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcBuildingElementProxy: AECARCHITECTURALELEMENT (35)
In: default BuildingStorey
Name
Label VAVR100
KLAPPE
Dichtung_Vierkantxxx_x_x
Ventilklappexxx_x_x
Dichtung_innenxxx_x_x
Achse Vierkant 8x8xxx_x_x
Dichtung_innenxxx_x_x-1
Sicherungsscheibexxx_x_x
Abschlusskappexxx_x_x
Screw 4.0x8mmxxx_x_x | SOLIDWORKS Custom Properties - Definition: M4 x 8mm; Nomenclature: M4 x 8mm v2; Part Number: M4 x 8mm; material property: ABS \X2\58516599\X0\; sets with these values: 2
Dichtung_Vierkantxxx_x_x-1
Screw 4.0x8mmxxx_x_x-1 | SOLIDWORKS Custom Properties - Definition: M4 x 8mm; Nomenclature: M4 x 8mm v2; Part Number: M4 x 8mm; material property: ABS \X2\58516599\X0\; sets with these values: 2
Sicherungsscheibexxx_x_x-1
Screw 4.0x8mmxxx_x_x-2 | SOLIDWORKS Custom Properties - Definition: M4 x 8mm; Nomenclature: M4 x 8mm v2; Part Number: M4 x 8mm; material property: ABS \X2\58516599\X0\; sets with these values: 2
Abschlusskappexxx_x_x-1
LMV-D3-MP
Isogehäuse
CROSS_DN100
CROSS_PIECE
CROSS_WING100
CROSS_PLUG
VSRV_Zapfen
CROSS_PLUG-1
CROSS_PLUG-2
CROSS_WING100-1
CROSS_WING100-2
CROSS_WING100-3
DB_DN100
BELIMO_MOTOR BRACKET | SOLIDWORKS Custom Properties - sets with these values: 2; Material: Verzinkter Stahl; Technische Referenz: KReiter; Weight: 0.15 kg
LDE_DN100
BLECHSCHRAUBE | SOLIDWORKS Custom Properties - Definition: design; Nomenclature: Fusion; Part Number: Fusion; sets with these values: 2
LDE_DN100-1
BLECHSCHRAUBE-1 | SOLIDWORKS Custom Properties - Definition: design; Nomenclature: Fusion; Part Number: Fusion; sets with these values: 2
BLECHSCHRAUBE-2 | SOLIDWORKS Custom Properties - Definition: design; Nomenclature: Fusion; Part Number: Fusion; sets with these values: 2
Teil7^VAV-RI100
