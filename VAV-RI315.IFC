Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\tmink\OneDrive - Vento\Bureaublad\A_Blazej\FINAL VAV\VAV-RI315.IFC
Time: 2025-03-05T16:08:20+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcBuildingElementProxy: AECARCHITECTURALELEMENT (32)
In: default BuildingStorey
Name
hose connection^VAV-RI315
BELIMO_MOTOR BRACKET_DN300-400 | SOLIDWORKS Custom Properties - Material: Verzinkter Stahl; Technische Referenz: KReiter; Weight: 0.15 kg; sets with these values: 2
LDE_DN315
LMV-D3-MP
DB_DN315
Label VAVR315
CROSS_DN315
CROSS_PIECE
CROSS_WING315
VSRV_Zapfen
CROSS_PLUG
CROSS_WING315-1
CROSS_WING315-2
CROSS_PLUG-1
CROSS_WING315-3
CROSS_PLUG-2
LDE_DN315-1
Dichtungen
2 x Dichtung_innenxxx_x_x
2 x Sicherungsscheibexxx_x_x
2 x Abschlusskappexxx_x_x
2 x Dichtung_Vierkantxxx_x_x
Dichtungen-1
KLAPPE315
BLECHSCHRAUBE | SOLIDWORKS Custom Properties - sets with these values: 2; Definition: design; Nomenclature: Fusion; Part Number: Fusion
BLECHSCHRAUBE-1 | SOLIDWORKS Custom Properties - sets with these values: 2; Definition: design; Nomenclature: Fusion; Part Number: Fusion
BLECHSCHRAUBE-2 | SOLIDWORKS Custom Properties - sets with these values: 2; Definition: design; Nomenclature: Fusion; Part Number: Fusion
Isogehäuse
