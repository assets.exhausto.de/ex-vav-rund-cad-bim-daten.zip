Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\tmink\OneDrive - Vento\Bureaublad\A_Blazej\FINAL VAV\VAV-R315.IFC
Time: 2025-03-06T12:21:30+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcBuildingElementProxy: AECARCHITECTURALELEMENT (31)
In: default BuildingStorey
Name
BELIMO_MOTOR BRACKET_DN300-400 | SOLIDWORKS Custom Properties - Material: Verzinkter Stahl; Technische Referenz: KReiter; Weight: 0.15 kg; sets with these values: 2
CROSS_DN315
CROSS_WING315
CROSS_WING315-1
CROSS_WING315-2
CROSS_PLUG
CROSS_PLUG-1
CROSS_PIECE
CROSS_PLUG-2
VSRV_Zapfen
CROSS_WING315-3
LDE_DN315
BLECHSCHRAUBE | SOLIDWORKS Custom Properties - sets with these values: 2; Definition: design; Nomenclature: Fusion; Part Number: Fusion
BLECHSCHRAUBE-1 | SOLIDWORKS Custom Properties - sets with these values: 2; Definition: design; Nomenclature: Fusion; Part Number: Fusion
LDE_DN315-1
LMV-D3-MP
BLECHSCHRAUBE-2 | SOLIDWORKS Custom Properties - sets with these values: 2; Definition: design; Nomenclature: Fusion; Part Number: Fusion
DB_DN315
Dichtungen
2 x Abschlusskappexxx_x_x
2 x Dichtung_innenxxx_x_x
2 x Dichtung_Vierkantxxx_x_x
2 x Sicherungsscheibexxx_x_x
Dichtungen-1
KLAPPE315
Label VAVR315
Teil9^VAV-R315
