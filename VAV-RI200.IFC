Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\tmink\OneDrive - Vento\Bureaublad\A_Blazej\FINAL VAV\VAV-RI200.IFC
Time: 2025-03-06T09:24:14+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcBuildingElementProxy: AECARCHITECTURALELEMENT (32)
In: default BuildingStorey
Name
Label VAVR200
LDE_DN200
CROSS_DN200
CROSS_WING200
CROSS_WING200-1
CROSS_WING200-2
CROSS_PLUG
CROSS_PLUG-1
VSRV_Zapfen
CROSS_WING200-3
CROSS_PIECE
CROSS_PLUG-2
LDE_DN200-1
BLECHSCHRAUBE | SOLIDWORKS Custom Properties - Definition: design; Nomenclature: Fusion; Part Number: Fusion; sets with these values: 2
LMV-D3-MP
Dichtungen
2 x Abschlusskappexxx_x_x
2 x Sicherungsscheibexxx_x_x
2 x Dichtung_Vierkantxxx_x_x
2 x Dichtung_innenxxx_x_x
BLECHSCHRAUBE-1 | SOLIDWORKS Custom Properties - Definition: design; Nomenclature: Fusion; Part Number: Fusion; sets with these values: 2
Dichtungen-1
DB_DN200
BELIMO_MOTOR BRACKET_DN150-200 | SOLIDWORKS Custom Properties - sets with these values: 2; Material: Verzinkter Stahl; Technische Referenz: KReiter; Weight: 0.15 kg
BLECHSCHRAUBE-2 | SOLIDWORKS Custom Properties - Definition: design; Nomenclature: Fusion; Part Number: Fusion; sets with these values: 2
KLAPPE200
Isogehäuse
HOSE con^VAV-RI200
