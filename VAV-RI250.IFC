Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\tmink\OneDrive - Vento\Bureaublad\A_Blazej\FINAL VAV\VAV-RI250.IFC
Time: 2025-03-06T08:56:27+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcBuildingElementProxy: AECARCHITECTURALELEMENT (32)
In: default BuildingStorey
Name
LMV-D3-MP
LDE_DN250
CROSS_DN250
CROSS_PIECE
CROSS_PLUG
CROSS_WING250
VSRV_Zapfen
CROSS_WING250-1
CROSS_PLUG-1
CROSS_WING250-2
CROSS_WING250-3
CROSS_PLUG-2
BLECHSCHRAUBE | SOLIDWORKS Custom Properties - Definition: design; Nomenclature: Fusion; Part Number: Fusion; sets with these values: 2
KLAPPE250
DB_DN250
BLECHSCHRAUBE-1 | SOLIDWORKS Custom Properties - Definition: design; Nomenclature: Fusion; Part Number: Fusion; sets with these values: 2
LDE_DN250-1
BELIMO_MOTOR BRACKET_DN300-400 | SOLIDWORKS Custom Properties - sets with these values: 2; Material: Verzinkter Stahl; Technische Referenz: KReiter; Weight: 0.15 kg
BLECHSCHRAUBE-2 | SOLIDWORKS Custom Properties - Definition: design; Nomenclature: Fusion; Part Number: Fusion; sets with these values: 2
Isogehäuse
Dichtungen
2 x Abschlusskappexxx_x_x
2 x Sicherungsscheibexxx_x_x
2 x Dichtung_Vierkantxxx_x_x
2 x Dichtung_innenxxx_x_x
Label VAVR250
Dichtungen-1
hose conn^VAV-RI250
