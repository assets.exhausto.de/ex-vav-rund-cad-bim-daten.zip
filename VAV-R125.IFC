Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\tmink\OneDrive - Vento\Bureaublad\A_Blazej\FINAL VAV\VAV-R125.IFC
Time: 2025-03-10T13:48:05+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcBuildingElementProxy: AECARCHITECTURALELEMENT (31)
In: default BuildingStorey
Name
Teil4^VAV-R125
DB_DN125
BELIMO_MOTOR BRACKET_DN125 | SOLIDWORKS Custom Properties - Material: Verzinkter Stahl; Technische Referenz: KReiter; Weight: 0,15 kg; sets with these values: 2
LDE_DN125
Label VAVR125
Dichtungen
2 x Sicherungsscheibexxx_x_x
2 x Abschlusskappexxx_x_x
2 x Dichtung_Vierkantxxx_x_x
2 x Dichtung_innenxxx_x_x
BLECHSCHRAUBE | SOLIDWORKS Custom Properties - sets with these values: 2; Definition: design; Nomenclature: Fusion; Part Number: Fusion
LDE_DN125-1
BLECHSCHRAUBE-1 | SOLIDWORKS Custom Properties - sets with these values: 2; Definition: design; Nomenclature: Fusion; Part Number: Fusion
LMV-D3-MP
KLAPPE125
CROSS_DN125
CROSS_PIECE
CROSS_WING125
CROSS_PLUG
VSRV_Zapfen
CROSS_PLUG-1
CROSS_WING125-1
CROSS_WING125-2
CROSS_WING125-3
CROSS_PLUG-2
BLECHSCHRAUBE-2 | SOLIDWORKS Custom Properties - sets with these values: 2; Definition: design; Nomenclature: Fusion; Part Number: Fusion
Dichtungen-1
