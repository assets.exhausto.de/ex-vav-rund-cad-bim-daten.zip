Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\tmink\OneDrive - Vento\Bureaublad\A_Blazej\FINAL VAV\VAV-R200.IFC
Time: 2025-03-10T13:27:06+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcBuildingElementProxy: AECARCHITECTURALELEMENT (31)
In: default BuildingStorey
Name
DB_DN200
Dichtungen
2 x Abschlusskappexxx_x_x
2 x Dichtung_innenxxx_x_x
2 x Dichtung_Vierkantxxx_x_x
2 x Sicherungsscheibexxx_x_x
Label VAVR200
CROSS_DN200
CROSS_PLUG
VSRV_Zapfen
CROSS_WING200
CROSS_WING200-1
CROSS_WING200-2
CROSS_WING200-3
CROSS_PIECE
CROSS_PLUG-1
CROSS_PLUG-2
Dichtungen-1
LDE_DN200
BLECHSCHRAUBE | SOLIDWORKS Custom Properties - Definition: design; Nomenclature: Fusion; Part Number: Fusion; sets with these values: 2
BELIMO_MOTOR BRACKET_DN150-200 | SOLIDWORKS Custom Properties - sets with these values: 2; Material: Verzinkter Stahl; Technische Referenz: KReiter; Weight: 0.15 kg
LDE_DN200-1
BLECHSCHRAUBE-1 | SOLIDWORKS Custom Properties - Definition: design; Nomenclature: Fusion; Part Number: Fusion; sets with these values: 2
BLECHSCHRAUBE-2 | SOLIDWORKS Custom Properties - Definition: design; Nomenclature: Fusion; Part Number: Fusion; sets with these values: 2
LMV-D3-MP
KLAPPE200
Teil2^VAV-R200
