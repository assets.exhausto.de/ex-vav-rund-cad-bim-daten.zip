Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\tmink\OneDrive - Vento\Bureaublad\A_Blazej\FINAL VAV\VAV-R250.IFC
Time: 2025-03-10T09:16:04+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcBuildingElementProxy: AECARCHITECTURALELEMENT (31)
In: default BuildingStorey
Name
BLECHSCHRAUBE | SOLIDWORKS Custom Properties - Definition: design; Nomenclature: Fusion; Part Number: Fusion; sets with these values: 2
Label VAVR250
BELIMO_MOTOR BRACKET_DN300-400 | SOLIDWORKS Custom Properties - sets with these values: 2; Material: Verzinkter Stahl; Technische Referenz: KReiter; Weight: 0.15 kg
BLECHSCHRAUBE-1 | SOLIDWORKS Custom Properties - Definition: design; Nomenclature: Fusion; Part Number: Fusion; sets with these values: 2
LDE_DN250
LMV-D3-MP
KLAPPE250
BLECHSCHRAUBE-2 | SOLIDWORKS Custom Properties - Definition: design; Nomenclature: Fusion; Part Number: Fusion; sets with these values: 2
Dichtungen
2 x Abschlusskappexxx_x_x
2 x Sicherungsscheibexxx_x_x
2 x Dichtung_innenxxx_x_x
2 x Dichtung_Vierkantxxx_x_x
Dichtungen-1
LDE_DN250-1
DB_DN250
CROSS_DN250
CROSS_PIECE
VSRV_Zapfen
CROSS_PLUG
CROSS_WING250
CROSS_WING250-1
CROSS_PLUG-1
CROSS_WING250-2
CROSS_WING250-3
CROSS_PLUG-2
Teil1^VAV-R250
