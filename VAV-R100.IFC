Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\tmink\OneDrive - Vento\Bureaublad\A_Blazej\FINAL VAV\VAV-R100.IFC
Time: 2025-03-10T14:17:28+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcBuildingElementProxy: AECARCHITECTURALELEMENT (34)
In: default BuildingStorey
Name
Teil5^VAV-R100
LMV-D3-MP
DB_DN100
CROSS_DN100
CROSS_WING100
CROSS_WING100-1
CROSS_PLUG
CROSS_WING100-2
CROSS_PLUG-1
CROSS_PIECE
CROSS_WING100-3
CROSS_PLUG-2
VSRV_Zapfen
LDE_DN100
BLECHSCHRAUBE | SOLIDWORKS Custom Properties - Definition: design; Nomenclature: Fusion; Part Number: Fusion; sets with these values: 2
BLECHSCHRAUBE-1 | SOLIDWORKS Custom Properties - Definition: design; Nomenclature: Fusion; Part Number: Fusion; sets with these values: 2
BLECHSCHRAUBE-2 | SOLIDWORKS Custom Properties - Definition: design; Nomenclature: Fusion; Part Number: Fusion; sets with these values: 2
BELIMO_MOTOR BRACKET | SOLIDWORKS Custom Properties - sets with these values: 2; Material: Verzinkter Stahl; Technische Referenz: KReiter; Weight: 0.15 kg
LDE_DN100-1
Label VAVR100
KLAPPE
Dichtung_Vierkantxxx_x_x
Dichtung_innenxxx_x_x
Sicherungsscheibexxx_x_x
Achse Vierkant 8x8xxx_x_x
Dichtung_Vierkantxxx_x_x-1
Ventilklappexxx_x_x
Screw 4.0x8mmxxx_x_x | SOLIDWORKS Custom Properties - Definition: M4 x 8mm; Nomenclature: M4 x 8mm v2; Part Number: M4 x 8mm; sets with these values: 2; material property: ABS \X2\58516599\X0\
Sicherungsscheibexxx_x_x-1
Abschlusskappexxx_x_x
Screw 4.0x8mmxxx_x_x-1 | SOLIDWORKS Custom Properties - Definition: M4 x 8mm; Nomenclature: M4 x 8mm v2; Part Number: M4 x 8mm; sets with these values: 2; material property: ABS \X2\58516599\X0\
Abschlusskappexxx_x_x-1
Screw 4.0x8mmxxx_x_x-2 | SOLIDWORKS Custom Properties - Definition: M4 x 8mm; Nomenclature: M4 x 8mm v2; Part Number: M4 x 8mm; sets with these values: 2; material property: ABS \X2\58516599\X0\
Dichtung_innenxxx_x_x-1
